## package/fpgautil/Config.in
```kconfig
config BR2_PACKAGE_FPGAUTIL
    bool "fpgautil"
    help
        FPGA bitstream load utility.
```
